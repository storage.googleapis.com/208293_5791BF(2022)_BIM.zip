Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-08-22T09:30:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 22 09:30:30 2022 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{59478EC9-3FFC-4A8A-936C-F1265816A757}\ifc * Database version: 5507 * Database creation date: Mon Aug 22 09:30:29 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 22 09:30:30 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 22 09:30:30 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 5791BF Washbasin faucet, 5791BF(2022):5791BF Washbasin faucet:18894
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 208.7 mm; NominalHeight: 173.025 mm; NominalWidth: 66.2929 mm
Type - General - Author: BIMStone; BIMObjectName: 5791BF(2022); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: 3; Uniclass2: Pr_40_30_96_106; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 3; VersionDate: 01/07/2022
Type - Green Building Properties - EAN Number: 6414150100703; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; Noise Class: I (ISO 3822); NRF Number: 4200594; Sales Package dimensions (LxWxH): 585 x 225 x 95; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/5791BF; URL REACH: http://static.oras.com/doc/reach; VVS Number: 701651834
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/5791BF; 3D View: https://static.oras.com/3D/5791BF; Catalog Drawing URL: http://static.oras.com/catdrw/5791BF; Dimension Drawing URL: http://static.oras.com/dimdrw/5791BF; FDV Document URL: http://www.oras.com/datasheet/5791BF/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/5791BF; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/5791BF; Interactive AR View URL: https://static.oras.com/AR/5791BF; Manufacturer: Oras; Market: International;Norway; Mobile Product Information URL: http://mpi.oras.com/5791BF; Model: 5791BF Washbasin faucet; Name_en: 5791BF Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 5791BF; Product Family: Oras Care; Product Image URL: http://static.oras.com/image/5791BF; Product URL: http://static.oras.com/5791BF; Spare-Part Information URL: http://static.oras.com/sp/5791BF; Technical DataSheet URL: http://www.oras.com/datasheet/5791BF/en; Type Name: 5791BF Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;3S-installation system for safe and simple mounting; Aerator: Standard aerator; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Flow Rate At 300kPa: 0.00635664 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Loop shape;Long shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Pressure Loss With Flow 01ls: 95000 Pa; Spout Projection: 114 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Temperature limiter (retrofittable); Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: Single lever; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5791BF(2022); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 5791BF; Name: 5791BF Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 67x210x180 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0563086 m2; Volume: 0.00181141 m3
Identity Data - Mark: 8
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 5791BF(2022): 5791BF Washbasin faucet; Family and Type: 5791BF(2022): 5791BF Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5791BF(2022): 5791BF Washbasin faucet; Type Id: 5791BF(2022): 5791BF Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
